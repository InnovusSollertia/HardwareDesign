* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.inc 'C:\Cadence\SPB_24.1\share\topxp\standard_step.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\tx_diff.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\tx_pkg.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\chan_xaui4.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\rx_pkg.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\rx_diff.sp'

X1 n1 n2 pwr1 in gnd
+ tx_differential

X2 n1 n2 n3 n4 gnd
+ txpkg

X3 n3 n4 n5 n6 gnd
+ channel

X4 n5 n6 n7 n8 gnd
+ rxpkg

X5 n7 n8 pwr2 gnd rxnode
+ rx_differential

Xstim in gnd standard_step tdel = 0n

Vtx1 pwr1 gnd 1
Vrx1 pwr2 gnd 1

.tran 2.000000p 30.000000n

.print V(in, gnd)		$ view Tx waveform
.print V(rxnode, gnd)		$ view Rx waveform
.print V(n7, gnd)		$ view Rx waveform
.print V(n8, gnd)		$ view Rx waveform

.end
