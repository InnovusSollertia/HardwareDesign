* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\PCB_PCB_tuned.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\PKG_PKG_tuned.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC0.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC2.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC3.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC4.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC5.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC6.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC7.sp'

X1 n1 gnd n2
+ PCB_BRD_2port_s2p_tuned

X2 n1 gnd
+ VRM

X3 n2 gnd n3 n4 n5 n6 n7 n8 n9 n10
+ PKG_PKG_9port_s9p_tuned

X4 n3 gnd
+ IC0

X5 n5 gnd
+ IC1

X6 n7 gnd
+ IC2

X7 n9 gnd
+ IC3

X8 n4 gnd
+ IC4

X9 n6 gnd
+ IC5

X10 n8 gnd
+ IC6

X11 n10 gnd
+ IC7

Port_1	n10	gnd	port=1	z0=1	ac=1

.ac POI 551
+ 100
+ 109.648
+ 120.226
+ 131.826
+ 144.544
+ 158.489
+ 173.78
+ 190.546
+ 208.93
+ 229.087
+ 251.189
+ 275.423
+ 301.995
+ 331.131
+ 363.078
+ 398.107
+ 436.516
+ 478.63
+ 524.807
+ 575.44
+ 630.957
+ 691.831
+ 758.578
+ 831.764
+ 912.011
+ 1000
+ 1096.48
+ 1202.26
+ 1318.26
+ 1445.44
+ 1584.89
+ 1737.8
+ 1905.46
+ 2089.3
+ 2290.87
+ 2511.89
+ 2754.23
+ 3019.95
+ 3311.31
+ 3630.78
+ 3981.07
+ 4365.16
+ 4786.3
+ 5248.07
+ 5754.4
+ 6309.57
+ 6918.31
+ 7585.78
+ 8317.64
+ 9120.11
+ 10000
+ 10964.8
+ 12022.6
+ 13182.6
+ 14454.4
+ 15848.9
+ 17378
+ 19054.6
+ 20893
+ 22908.7
+ 25118.9
+ 27542.3
+ 30199.5
+ 33113.1
+ 36307.8
+ 39810.7
+ 43651.6
+ 47863
+ 52480.7
+ 57544
+ 63095.7
+ 69183.1
+ 75857.8
+ 83176.4
+ 91201.1
+ 100000
+ 109648
+ 120226
+ 131826
+ 144544
+ 158489
+ 173780
+ 190546
+ 208930
+ 229087
+ 251189
+ 275423
+ 301995
+ 331131
+ 363078
+ 398107
+ 436516
+ 478630
+ 524807
+ 575440
+ 630957
+ 691831
+ 758578
+ 831764
+ 912011
+ 1e+06
+ 1.09648e+06
+ 1.20226e+06
+ 1.31826e+06
+ 1.44544e+06
+ 1.58489e+06
+ 1.7378e+06
+ 1.90546e+06
+ 2.0893e+06
+ 2.29087e+06
+ 2.51189e+06
+ 2.75423e+06
+ 3.01995e+06
+ 3.31131e+06
+ 3.63078e+06
+ 3.98107e+06
+ 4.36516e+06
+ 4.7863e+06
+ 5.24807e+06
+ 5.7544e+06
+ 6.30957e+06
+ 6.91831e+06
+ 7.58578e+06
+ 8.31764e+06
+ 9.12011e+06
+ 1e+07
+ 1.04e+07
+ 1.08e+07
+ 1.12e+07
+ 1.16e+07
+ 1.2e+07
+ 1.24e+07
+ 1.28e+07
+ 1.32e+07
+ 1.36e+07
+ 1.4e+07
+ 1.44e+07
+ 1.48e+07
+ 1.52e+07
+ 1.56e+07
+ 1.6e+07
+ 1.64e+07
+ 1.68e+07
+ 1.72e+07
+ 1.76e+07
+ 1.8e+07
+ 1.84e+07
+ 1.88e+07
+ 1.92e+07
+ 1.96e+07
+ 2e+07
+ 2.04e+07
+ 2.08e+07
+ 2.12e+07
+ 2.16e+07
+ 2.2e+07
+ 2.24e+07
+ 2.28e+07
+ 2.32e+07
+ 2.36e+07
+ 2.4e+07
+ 2.44e+07
+ 2.48e+07
+ 2.52e+07
+ 2.56e+07
+ 2.6e+07
+ 2.64e+07
+ 2.68e+07
+ 2.72e+07
+ 2.76e+07
+ 2.8e+07
+ 2.84e+07
+ 2.88e+07
+ 2.92e+07
+ 2.96e+07
+ 3e+07
+ 3.04e+07
+ 3.08e+07
+ 3.12e+07
+ 3.16e+07
+ 3.2e+07
+ 3.24e+07
+ 3.28e+07
+ 3.32e+07
+ 3.36e+07
+ 3.4e+07
+ 3.44e+07
+ 3.48e+07
+ 3.52e+07
+ 3.56e+07
+ 3.6e+07
+ 3.64e+07
+ 3.68e+07
+ 3.72e+07
+ 3.76e+07
+ 3.8e+07
+ 3.84e+07
+ 3.88e+07
+ 3.92e+07
+ 3.96e+07
+ 4e+07
+ 4.04e+07
+ 4.08e+07
+ 4.12e+07
+ 4.16e+07
+ 4.2e+07
+ 4.24e+07
+ 4.28e+07
+ 4.32e+07
+ 4.36e+07
+ 4.4e+07
+ 4.44e+07
+ 4.48e+07
+ 4.52e+07
+ 4.56e+07
+ 4.6e+07
+ 4.64e+07
+ 4.68e+07
+ 4.72e+07
+ 4.76e+07
+ 4.8e+07
+ 4.84e+07
+ 4.88e+07
+ 4.92e+07
+ 4.96e+07
+ 5e+07
+ 5.2e+07
+ 5.4e+07
+ 5.6e+07
+ 5.8e+07
+ 6e+07
+ 6.2e+07
+ 6.4e+07
+ 6.6e+07
+ 6.8e+07
+ 7e+07
+ 7.2e+07
+ 7.4e+07
+ 7.6e+07
+ 7.8e+07
+ 8e+07
+ 8.2e+07
+ 8.4e+07
+ 8.6e+07
+ 8.8e+07
+ 9e+07
+ 9.2e+07
+ 9.4e+07
+ 9.6e+07
+ 9.8e+07
+ 1e+08
+ 1.02e+08
+ 1.04e+08
+ 1.06e+08
+ 1.08e+08
+ 1.1e+08
+ 1.12e+08
+ 1.14e+08
+ 1.16e+08
+ 1.18e+08
+ 1.2e+08
+ 1.22e+08
+ 1.24e+08
+ 1.26e+08
+ 1.28e+08
+ 1.3e+08
+ 1.32e+08
+ 1.34e+08
+ 1.36e+08
+ 1.38e+08
+ 1.4e+08
+ 1.42e+08
+ 1.44e+08
+ 1.46e+08
+ 1.48e+08
+ 1.5e+08
+ 1.52e+08
+ 1.54e+08
+ 1.56e+08
+ 1.58e+08
+ 1.6e+08
+ 1.62e+08
+ 1.64e+08
+ 1.66e+08
+ 1.68e+08
+ 1.7e+08
+ 1.72e+08
+ 1.74e+08
+ 1.76e+08
+ 1.78e+08
+ 1.8e+08
+ 1.82e+08
+ 1.84e+08
+ 1.86e+08
+ 1.88e+08
+ 1.9e+08
+ 1.92e+08
+ 1.94e+08
+ 1.96e+08
+ 1.98e+08
+ 2e+08
+ 2.02e+08
+ 2.04e+08
+ 2.06e+08
+ 2.08e+08
+ 2.1e+08
+ 2.12e+08
+ 2.14e+08
+ 2.16e+08
+ 2.18e+08
+ 2.2e+08
+ 2.22e+08
+ 2.24e+08
+ 2.26e+08
+ 2.28e+08
+ 2.3e+08
+ 2.32e+08
+ 2.34e+08
+ 2.36e+08
+ 2.38e+08
+ 2.4e+08
+ 2.42e+08
+ 2.44e+08
+ 2.46e+08
+ 2.48e+08
+ 2.5e+08
+ 2.52e+08
+ 2.54e+08
+ 2.56e+08
+ 2.58e+08
+ 2.6e+08
+ 2.62e+08
+ 2.64e+08
+ 2.66e+08
+ 2.68e+08
+ 2.7e+08
+ 2.72e+08
+ 2.74e+08
+ 2.76e+08
+ 2.78e+08
+ 2.8e+08
+ 2.82e+08
+ 2.84e+08
+ 2.86e+08
+ 2.88e+08
+ 2.9e+08
+ 2.92e+08
+ 2.94e+08
+ 2.96e+08
+ 2.98e+08
+ 3e+08
+ 3.02e+08
+ 3.04e+08
+ 3.06e+08
+ 3.08e+08
+ 3.1e+08
+ 3.12e+08
+ 3.14e+08
+ 3.16e+08
+ 3.18e+08
+ 3.2e+08
+ 3.22e+08
+ 3.24e+08
+ 3.26e+08
+ 3.28e+08
+ 3.3e+08
+ 3.32e+08
+ 3.34e+08
+ 3.36e+08
+ 3.38e+08
+ 3.4e+08
+ 3.42e+08
+ 3.44e+08
+ 3.46e+08
+ 3.48e+08
+ 3.5e+08
+ 3.52e+08
+ 3.54e+08
+ 3.56e+08
+ 3.58e+08
+ 3.6e+08
+ 3.62e+08
+ 3.64e+08
+ 3.66e+08
+ 3.68e+08
+ 3.7e+08
+ 3.72e+08
+ 3.74e+08
+ 3.76e+08
+ 3.78e+08
+ 3.8e+08
+ 3.82e+08
+ 3.84e+08
+ 3.86e+08
+ 3.88e+08
+ 3.9e+08
+ 3.92e+08
+ 3.94e+08
+ 3.96e+08
+ 3.98e+08
+ 4e+08
+ 4.02e+08
+ 4.04e+08
+ 4.06e+08
+ 4.08e+08
+ 4.1e+08
+ 4.12e+08
+ 4.14e+08
+ 4.16e+08
+ 4.18e+08
+ 4.2e+08
+ 4.22e+08
+ 4.24e+08
+ 4.26e+08
+ 4.28e+08
+ 4.3e+08
+ 4.32e+08
+ 4.34e+08
+ 4.36e+08
+ 4.38e+08
+ 4.4e+08
+ 4.42e+08
+ 4.44e+08
+ 4.46e+08
+ 4.48e+08
+ 4.5e+08
+ 4.52e+08
+ 4.54e+08
+ 4.56e+08
+ 4.58e+08
+ 4.6e+08
+ 4.62e+08
+ 4.64e+08
+ 4.66e+08
+ 4.68e+08
+ 4.7e+08
+ 4.72e+08
+ 4.74e+08
+ 4.76e+08
+ 4.78e+08
+ 4.8e+08
+ 4.82e+08
+ 4.84e+08
+ 4.86e+08
+ 4.88e+08
+ 4.9e+08
+ 4.92e+08
+ 4.94e+08
+ 4.96e+08
+ 4.98e+08
+ 5e+08
+ 5.05e+08
+ 5.1e+08
+ 5.15e+08
+ 5.2e+08
+ 5.25e+08
+ 5.3e+08
+ 5.35e+08
+ 5.4e+08
+ 5.45e+08
+ 5.5e+08
+ 5.55e+08
+ 5.6e+08
+ 5.65e+08
+ 5.7e+08
+ 5.75e+08
+ 5.8e+08
+ 5.85e+08
+ 5.9e+08
+ 5.95e+08
+ 6e+08
+ 6.05e+08
+ 6.1e+08
+ 6.15e+08
+ 6.2e+08
+ 6.25e+08
+ 6.3e+08
+ 6.35e+08
+ 6.4e+08
+ 6.45e+08
+ 6.5e+08
+ 6.55e+08
+ 6.6e+08
+ 6.65e+08
+ 6.7e+08
+ 6.75e+08
+ 6.8e+08
+ 6.85e+08
+ 6.9e+08
+ 6.95e+08
+ 7e+08
+ 7.05e+08
+ 7.1e+08
+ 7.15e+08
+ 7.2e+08
+ 7.25e+08
+ 7.3e+08
+ 7.35e+08
+ 7.4e+08
+ 7.45e+08
+ 7.5e+08
+ 7.55e+08
+ 7.6e+08
+ 7.65e+08
+ 7.7e+08
+ 7.75e+08
+ 7.8e+08
+ 7.85e+08
+ 7.9e+08
+ 7.95e+08
+ 8e+08
+ 8.05e+08
+ 8.1e+08
+ 8.15e+08
+ 8.2e+08
+ 8.25e+08
+ 8.3e+08
+ 8.35e+08
+ 8.4e+08
+ 8.45e+08
+ 8.5e+08
+ 8.55e+08
+ 8.6e+08
+ 8.65e+08
+ 8.7e+08
+ 8.75e+08
+ 8.8e+08
+ 8.85e+08
+ 8.9e+08
+ 8.95e+08
+ 9e+08
+ 9.05e+08
+ 9.1e+08
+ 9.15e+08
+ 9.2e+08
+ 9.25e+08
+ 9.3e+08
+ 9.35e+08
+ 9.4e+08
+ 9.45e+08
+ 9.5e+08
+ 9.55e+08
+ 9.6e+08
+ 9.65e+08
+ 9.7e+08
+ 9.75e+08
+ 9.8e+08
+ 9.85e+08
+ 9.9e+08
+ 9.95e+08
+ 1e+09
.lin filename=S_para format=touchstone

.end
