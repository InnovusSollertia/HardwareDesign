* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\PCB_PCB_tuned.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\PKG_PKG_tuned.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC0.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC2.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC3.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC4.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC5.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC6.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ac_multi_ic\result\IC7.sp'

X1 n1 gnd n2
+ PCB_BRD_2port_s2p_tuned

X2 n1 gnd
+ VRM

X3 n2 gnd n3 n4 n5 n6 n7 n8 n9 n10
+ PKG_PKG_9port_s9p_tuned

X4 n3 gnd
+ IC0

X5 n5 gnd
+ IC1

X6 n7 gnd
+ IC2

X7 n9 gnd
+ IC3

X8 n4 gnd
+ IC4

X9 n6 gnd
+ IC5

X10 n8 gnd
+ IC6

X11 n10 gnd
+ IC7

.tran 2.000000p 56.568000n

.print V(n10, gnd)		$ IC7, Signal: a

.end
