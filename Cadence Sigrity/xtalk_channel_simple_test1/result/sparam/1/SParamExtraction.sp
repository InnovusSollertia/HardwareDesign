* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk_channel_simple_test1\result\TLine1.sp'

X7 n1 n2 n3 n4 n5 n6 gnd n7 n8 n9 n10 n11 n12 gnd
+ TLine1

Port_1	n11	gnd	port=1	z0=50	ac=1
Port_2	n12	gnd	port=2	z0=50
Port_3	n3	gnd	port=3	z0=50
Port_4	n4	gnd	port=4	z0=50
Port_5	n1	gnd	port=5	z0=50
Port_6	n2	gnd	port=6	z0=50
Port_7	n5	gnd	port=7	z0=50
Port_8	n6	gnd	port=8	z0=50
Port_9	n9	gnd	port=9	z0=50
Port_10	n10	gnd	port=10	z0=50
Port_11	n7	gnd	port=11	z0=50
Port_12	n8	gnd	port=12	z0=50

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
