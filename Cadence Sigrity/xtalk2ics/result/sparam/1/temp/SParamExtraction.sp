* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\W1.sp'

X3 n1 n2 n3 gnd n4 n5 n6 gnd
+ W1

Port_1	n2	gnd	port=1	z0=50	ac=1
Port_2	n3	gnd	port=2	z0=50
Port_3	n1	gnd	port=3	z0=50
Port_4	n4	gnd	port=4	z0=50
Port_5	n5	gnd	port=5	z0=50
Port_6	n6	gnd	port=6	z0=50

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
