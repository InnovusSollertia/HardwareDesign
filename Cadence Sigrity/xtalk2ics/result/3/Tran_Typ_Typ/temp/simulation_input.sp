* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.inc 'C:\Cadence\SPB_24.1\share\topxp\default_models\rx_spice.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\3\Tran_Typ_Typ\simulation_ibis_definition.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\default_models\via.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace3.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM2.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Clarity.sp'

X1 n1 n2 gnd
+ via_single

X2 n3 n4 gnd
+ via_single

X3 n2 gnd n5 gnd n6
+ Trace

X4 n4 gnd n7 gnd n8 n9 n10
+ Trace1

X5 n11 n12 n13 n14 n15 n16 n17 n18 n19 n20 n21 n22 n23 n24 n25 n26 n27 n28 n29 n30
+ n31 n32 n33 n34 n35 n36 n37 n38 n39 n40 n41 n42 n43 n44 n45 n46 n47 n48 gnd gnd
+ Ctrl_transmit

X6 n49 n50 n51 n52 n53 n54 n55 n56 n57 n58 n59 n60 n61 n62 n63 n64 n65 n66 n67 n68
+ n69 n70 n71 n72 n73 n74 n75 n76 n77 n78 n79 n80 n81 n82 n83 n84 n85 n86 gnd gnd
+ n87 n88 n89 n90 n91 n92 n93 n94 n95 n96 n97 n98 n99 n100 n101 n102 n103 n104 n105 n106
+ n107 n108 n109 n110 n111 n112 n113 n114 n115 n116 n117 n118 n119 n120 n121 n122 n123 n124 gnd gnd
+ Ctrl_Controller_OnDie_RC

X7 n125 n126 n127 n128 n129 n130 n131 n132 n133 n134 n135 n136 n137 n138 n139 n140 n141 n142 n143 n144
+ n145 n146 n147 n148 n149 n150 n151 n152 n153 n154 n155 n156 n157 n158 n159 n160 n161 n162 gnd gnd
+ n163 n164 n165 n166 n167 n168 n169 n170 n171 n172 n173 n174 n175 n176 n177 n178 n179 n180 n181 n182
+ n183 n184 n185 n186 n187 n188 n189 n190 n191 n192 n193 n194 n195 n196 n197 n198 n161 n162 gnd gnd
+ Ctrl_Controller_Pin_RLC
+ R_pkg = 1.0146
+ L_pkg = 7.151e-9
+ C_pkg = 3.058e-12

X8 n199 gnd n1 gnd n200 n201 n202
+ Trace3

X9 n7 n203 n204 n205 n206 n207 n208 n209 n210 n211 n212 n213 n214 n215 n216 n217 n218 n219 n220 n221
+ n222 n223 n224 n225 n226 n227 n228 n229 n230 n231 n232 gnd
+ Mem_receive

X10 n10 gnd
+ VRM
+ Voltage = 1.0

X11 n202 gnd
+ VRM2
+ Voltage = 1.0

X12 n233 n234 n235 n236 gnd
+ Clarity_diff_trace_FIT_S4P

R_n3_gnd n3 gnd 50		$ Auto-terminate 1 of Via1
R_n5_gnd n5 gnd 50		$ Auto-terminate a2 of Trace
R_n6_gnd n6 gnd 1e+08		$ Auto-terminate pwr of Trace
R_n8_gnd n8 gnd 1e+08		$ Auto-terminate pwr_1 of Trace1
R_n9_gnd n9 gnd 1e+08		$ Auto-terminate pwr_2 of Trace1
R_n199_gnd n199 gnd 50		$ Auto-terminate a1 of Trace3
R_n200_gnd n200 gnd 1e+08		$ Auto-terminate pwr_1 of Trace3
R_n201_gnd n201 gnd 1e+08		$ Auto-terminate pwr_2 of Trace3
R_n233_gnd n233 gnd 50		$ Auto-terminate Port_Group1 of Clarity
R_n234_gnd n234 gnd 50		$ Auto-terminate Port_Group2 of Clarity
R_n235_gnd n235 gnd 50		$ Auto-terminate Port_Group3 of Clarity
R_n236_gnd n236 gnd 50		$ Auto-terminate Port_Group4 of Clarity

.tran 3.571000p 20.000000n

.print V(n7, gnd)		$ Mem, Signal: DQ13

.end
