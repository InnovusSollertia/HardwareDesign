* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\TL.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\TL1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\Trace.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\Trace1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\Trace2.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\default_models\via_diff.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\VRM1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\VRM2.sp'

X5 n1 n2 n3 n4 gnd
+ TL

X6 n5 n6 n7 n8 gnd
+ TL1

X7 n9 n10 gnd n11 n12 gnd n13 n14 n15
+ Trace

X8 n16 n17 gnd n18 n19 gnd n20 n21 n22
+ Trace1

X9 n23 n24 gnd n25 n26 gnd n27 n28 n29
+ Trace2

X10 n18 n23 n19 n24 gnd
+ via_diff

X11 n15 gnd
+ VRM1

X12 n29 gnd
+ VRM

X13 n22 gnd
+ VRM2

R_n3_gnd n3 gnd 50		$ Auto-terminate 2 of TL
R_n4_gnd n4 gnd 50		$ Auto-terminate 4 of TL
R_n5_gnd n5 gnd 50		$ Auto-terminate 1 of TL1
R_n6_gnd n6 gnd 50		$ Auto-terminate 3 of TL1
R_n8_gnd n8 gnd 50		$ Auto-terminate 4 of TL1
R_n9_gnd n9 gnd 50		$ Auto-terminate a1 of Trace
R_n10_gnd n10 gnd 50		$ Auto-terminate b1 of Trace
R_n11_gnd n11 gnd 50		$ Auto-terminate a2 of Trace
R_n12_gnd n12 gnd 50		$ Auto-terminate b2 of Trace
R_n13_gnd n13 gnd 1e+08		$ Auto-terminate pwr_1 of Trace
R_n14_gnd n14 gnd 1e+08		$ Auto-terminate pwr_2 of Trace
R_n16_gnd n16 gnd 50		$ Auto-terminate a1 of Trace1
R_n17_gnd n17 gnd 50		$ Auto-terminate b1 of Trace1
R_n20_gnd n20 gnd 1e+08		$ Auto-terminate pwr_1 of Trace1
R_n21_gnd n21 gnd 1e+08		$ Auto-terminate pwr_2 of Trace1
R_n25_gnd n25 gnd 50		$ Auto-terminate a2 of Trace2
R_n26_gnd n26 gnd 50		$ Auto-terminate b2 of Trace2
R_n27_gnd n27 gnd 1e+08		$ Auto-terminate pwr_1 of Trace2
R_n28_gnd n28 gnd 1e+08		$ Auto-terminate pwr_2 of Trace2

Port_1	n2	gnd	port=1	z0=50	ac=1
Port_2	n1	gnd	port=2	z0=50
Port_4	n7	gnd	port=3	z0=50

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
