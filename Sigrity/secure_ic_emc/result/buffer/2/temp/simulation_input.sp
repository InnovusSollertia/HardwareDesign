* Net list generated by Topology Workbench.

.inc 'D:\Projects\HardwareDesign\Sigrity\secure_ic_emc\result\buffer\2\simulation_ibis_definition.sp'

X1 n1 n2 n3 n4 n5 n6 n7 n8 n9 n10 n11 n12 n13 n14 n15 n16 n17 n18 n19 n20 n21 n22
+ n23 n24 n25 n26 n27 n28 n29 n30 n31 n32 n33 n34 n35 n36 n37 n38 gnd gnd Ctrl_Controller
X2 n1 n2 n3 n4 n5 n6 n7 n8 n9 n10 n11 n12 n13 n14 n15 n16 n17 n18 n19 n20 n21 n22
+ n23 n24 n25 n26 n27 n28 n29 n30 n31 n32 n33 n34 n35 n36 n37 n38 gnd gnd Ctrl_Controller_Test_Fixture

.tran 20.000000p 20.000000n
.print V(n10, gnd)
.print V(n7, gnd)
.print V(n4, gnd)
.print V(n8, gnd)
.print V(n9, gnd)
.print V(n6, gnd)
.print V(n5, gnd)
.print V(n3, gnd)
.print V(n26, gnd)
.print V(n23, gnd)
.print V(n25, gnd)
.print V(n24, gnd)
.print V(n17, gnd)
.print V(n20, gnd)
.print V(n18, gnd)
.print V(n19, gnd)
.print V(n27, gnd)
.print V(n30, gnd)
.print V(n28, gnd)
.print V(n29, gnd)
.print V(n36, gnd)
.print V(n33, gnd)
.print V(n35, gnd)
.print V(n34, gnd)
.print V(n16, gnd)
.print V(n2, gnd)
.print V(n12, gnd)
.print V(n14, gnd)
.print V(n22, gnd)
.print V(n31, gnd)
.print V(n15, gnd)
.print V(n1, gnd)
.print V(n11, gnd)
.print V(n13, gnd)
.print V(n21, gnd)
.print V(n32, gnd)
.print V(n16, n15)
.print V(n2, n1)
.print V(n12, n11)
.print V(n14, n13)
.print V(n22, n21)
.print V(n31, n32)

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.end
