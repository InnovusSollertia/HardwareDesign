* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\4\Tran_Typ_Typ\simulation_ibis_definition.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\default_models\via.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace3.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM2.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Clarity.sp'

X1 n1 n2 gnd
+ via_single

X2 n3 n4 gnd
+ via_single

X3 n2 gnd n5 gnd n6
+ Trace

X4 n4 gnd n7 gnd n8 n9 n10
+ Trace1

X5 n11 gnd n1 gnd n12 n13 n14
+ Trace3

X6 n10 gnd
+ VRM
+ Voltage = 1.0

X7 n14 gnd
+ VRM2
+ Voltage = 1.0

X8 n15 n16 n17 n18 gnd
+ Clarity_diff_trace_FIT_S4P

X9 n11 n12 gnd
+ Tx_transmit

X10 n7 n9 gnd
+ Rx_receive

R_n3_gnd n3 gnd 50		$ Auto-terminate 1 of Via1
R_n5_gnd n5 gnd 50		$ Auto-terminate a2 of Trace
R_n6_gnd n6 gnd 1e+08		$ Auto-terminate pwr of Trace
R_n8_gnd n8 gnd 1e+08		$ Auto-terminate pwr_1 of Trace1
R_n13_gnd n13 gnd 1e+08		$ Auto-terminate pwr_2 of Trace3
R_n15_gnd n15 gnd 50		$ Auto-terminate Port_Group1 of Clarity
R_n16_gnd n16 gnd 50		$ Auto-terminate Port_Group2 of Clarity
R_n17_gnd n17 gnd 50		$ Auto-terminate Port_Group3 of Clarity
R_n18_gnd n18 gnd 50		$ Auto-terminate Port_Group4 of Clarity

.tran 3.571000p 12.000000n

.print V(n11, gnd)		$ Tx, Signal: TX
.print V(n7, gnd)		$ Rx, Signal: RX

.end
