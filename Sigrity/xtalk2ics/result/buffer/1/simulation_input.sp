* Net list generated by Topology Workbench.

.inc 'C:\Cadence\SPB_24.1\share\topxp\Explorer\xtalk_3_signals\tx_Thev_drvr.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\buffer\1\simulation_ibis_definition.sp'

X1 n1 n2 n3 n4 n5 n6 gnd Tx1_SSI_IBIS
X2 n1 n2 n3 n4 n5 n6 gnd Tx1_SSI_IBIS_Test_Fixture

.tran 20.000000p 20.000000n
.print V(n3, gnd)
.print V(n4, gnd)
.print V(n5, gnd)
.print V(n1, gnd)
.print V(n2, gnd)
.print V(n1, n2)

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.end
