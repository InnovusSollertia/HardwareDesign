* Net list generated by Topology Workbench.

.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\buffer\4\simulation_ibis_definition.sp'

X1 n1 n2 gnd Tx_Default
X2 n1 n2 gnd Tx_Default_Test_Fixture

.tran 3.571000p 20.000000n
.print V(n1, gnd)

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.end
