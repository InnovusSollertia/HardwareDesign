* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
* .option delmax=10p

.inc 'C:\Cadence\SPB_24.1\share\topxp\Explorer\xtalk_3_signals\tx_Thev_drvr.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\Explorer\xtalk_3_signals\rx_spice_term.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\1\Tran_Typ_Typ\simulation_ibis_definition.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\W1.sp'

X1 n1 n2 n3 n4 n5 n6 gnd
+ Tx1_transmit

X2 n7 n8 n9 n10 n11 n12 gnd n13 n14 n15
+ Rx1_receive

X3 n3 n4 n5 gnd n9 n10 n11 gnd
+ W1

.tran 20.000000p 12.000000n

.print V(n3, gnd)		$ Tx1, Signal: ABC
.print V(n4, gnd)		$ Tx1, Signal: DEF
.print V(n5, gnd)		$ Tx1, Signal: GHI
.print V(n15, gnd)		$ Rx1, Signal: RST
.print V(n14, gnd)		$ Rx1, Signal: UVW
.print V(n13, gnd)		$ Rx1, Signal: XYZ

.end
