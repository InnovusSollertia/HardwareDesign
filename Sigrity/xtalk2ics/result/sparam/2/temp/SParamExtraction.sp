* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'C:\Cadence\SPB_24.1\share\topxp\default_models\via.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace1.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\Trace3.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\xtalk2ics\result\VRM2.sp'

X1 n1 n2 gnd
+ via_single

X2 n3 n4 gnd
+ via_single

X3 n2 gnd n3 gnd n5
+ Trace

X4 n4 gnd n6 gnd n7 n8 n9
+ Trace1

X6 n10 gnd n1 gnd n11 n12 n13
+ Trace3

X8 n9 gnd
+ VRM

X9 n13 gnd
+ VRM2

R_n5_gnd n5 gnd 1e+08		$ Auto-terminate pwr of Trace
R_n7_gnd n7 gnd 1e+08		$ Auto-terminate pwr_1 of Trace1
R_n8_gnd n8 gnd 1e+08		$ Auto-terminate pwr_2 of Trace1
R_n10_gnd n10 gnd 50		$ Auto-terminate a1 of Trace3
R_n11_gnd n11 gnd 1e+08		$ Auto-terminate pwr_1 of Trace3
R_n12_gnd n12 gnd 1e+08		$ Auto-terminate pwr_2 of Trace3

Port_1	n6	gnd	port=1	z0=50	ac=1

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
