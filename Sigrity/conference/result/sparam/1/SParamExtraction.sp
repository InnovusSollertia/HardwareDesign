* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\chan_12port.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\txpkg_12port.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\rxpkg_12port.sp'

X1 n1 n2 n3 n4 n5 n6 n7 n8 n9 n10 n11 n12 gnd
+ channel

X2 n13 n14 n1 n2 n15 n16 n5 n6 n17 n18 n9 n10 gnd
+ txpkg

X3 n3 n4 n19 n20 n7 n8 n21 n22 n11 n12 n23 n24 gnd
+ rxpkg

Port_1	n17	gnd	port=1	z0=50	ac=1
Port_2	n18	gnd	port=2	z0=50
Port_3	n15	gnd	port=3	z0=50
Port_4	n16	gnd	port=4	z0=50
Port_5	n13	gnd	port=5	z0=50
Port_6	n14	gnd	port=6	z0=50
Port_7	n23	gnd	port=7	z0=50
Port_8	n24	gnd	port=8	z0=50
Port_9	n21	gnd	port=9	z0=50
Port_10	n22	gnd	port=10	z0=50
Port_11	n19	gnd	port=11	z0=50
Port_12	n20	gnd	port=12	z0=50

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
