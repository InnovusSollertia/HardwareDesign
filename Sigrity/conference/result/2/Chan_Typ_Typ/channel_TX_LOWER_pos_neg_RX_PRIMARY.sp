* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
*.option delmax=1p

.inc 'C:\Cadence\SPB_24.1\share\topxp\standard_step.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\tx_bhvr.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\txpkg_12port.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\chan_12port.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\rxpkg_12port.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\xtalk_channel_sparam\rx_bhvr.sp'

X1 n1 n2 pwr1 in gnd
+ nmos_diff_tx

X2 n3 n4 n5 n6 n7 n8 n9 n10 n1 n2 n11 n12 gnd
+ txpkg

X3 n5 n6 n13 n14 n9 n10 n15 n16 n11 n12 n17 n18 gnd
+ channel

X4 n7 n8 pwr2 gnd gnd
+ nmos_diff_tx

X5 n3 n4 pwr3 gnd gnd
+ nmos_diff_tx

X6 n13 n14 n19 n20 n15 n16 n21 n22 n17 n18 n23 n24 gnd
+ rxpkg

X7 n21 n22 pwr4 gnd rxnode
+ nmos_diff_rx

X8 n19 n20 pwr5 gnd n25
+ nmos_diff_rx

X9 n23 n24 pwr6 gnd n26
+ nmos_diff_rx

Xstim in gnd standard_step tdel = 0n

Vtx1 pwr1 gnd 1
Vtx2 pwr2 gnd 1
Vtx3 pwr3 gnd 1
Vrx1 pwr4 gnd 1
Vrx2 pwr5 gnd 1
Vrx3 pwr6 gnd 1

.tran 2.000000p 30.000000n

.print V(in, gnd)		$ view Tx waveform
.print V(rxnode, gnd)		$ view Rx waveform
.print V(n21, gnd)		$ view Rx waveform
.print V(n22, gnd)		$ view Rx waveform

.end
