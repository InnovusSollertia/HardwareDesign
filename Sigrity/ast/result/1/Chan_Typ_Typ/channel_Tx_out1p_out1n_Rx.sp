* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
*.option delmax=1p

.inc 'C:\Cadence\SPB_24.1\share\topxp\standard_step.sp'
.inc '.\channel_Tx_out1p_out1n_Rx_ibis.sp'
.inc 'D:\Projects\HardwareDesign\Sigrity\ast\result\S1.sp'

X1 n1 n2 pwr1 gnd in
+ Tx_ABC_Serdes

X2 n1 gnd n2 n3 gnd n4
+ S1_sparams_4port_bnp

X3 n3 n4 pwr2 gnd rxnode
+ Rx_ABC_Serdes

Xstim in gnd standard_step tdel = 0n

.tran 2.000000p 28.000000n

.print V(in, gnd)		$ view Tx waveform
.print V(rxnode, gnd)		$ view Rx waveform
.print V(n3, gnd)		$ view Rx waveform
.print V(n4, gnd)		$ view Rx waveform

.end
