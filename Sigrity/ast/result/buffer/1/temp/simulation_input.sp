* Net list generated by Topology Workbench.

.inc 'D:\Projects\HardwareDesign\Sigrity\ast\result\buffer\1\simulation_ibis_definition.sp'

X1 n1 n2 n3 gnd Tx_ABC_Serdes
X2 n1 n2 n3 gnd Tx_ABC_Serdes_Test_Fixture

.tran 2.000000p 2.000000n
.print V(n1, gnd)
.print V(n2, gnd)
.print V(n1, n2)

* Add global .option and .include commands here.
* They'll be used for time domain characterization.
*.option delmax=1p

.end
