* Net list generated by Topology Workbench, Cadence Design Systems Inc.

* Simulator: SPDSIM
* Simulator Path: C:\Cadence\Sigrity2024.0\tools\bin\SPDsimCon.exe

.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\chan_xaui4.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\tx_pkg.sp'
.inc 'C:\Cadence\SPB_24.1\share\topxp\SerialLink\pcb_thru\rx_pkg.sp'

X2 n1 n2 n3 n4 gnd
+ channel

X4 n5 n6 n1 n2 gnd
+ txpkg

X5 n3 n4 n7 n8 gnd
+ rxpkg

Port_1	n5	gnd	port=1	z0=50	ac=1
Port_2	n6	gnd	port=2	z0=50
Port_3	n7	gnd	port=3	z0=50
Port_4	n8	gnd	port=4	z0=50

.ac lin 10 0 1e+09
.lin filename=S_para format=bnp

.end
